# Keil uVision project projects.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: projects
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS;.\User;.\Libraries\STM32F10x_StdPeriph_Driver;.\System;.\Hardware;.\HAL;.\Algorithm;.\Application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
  group library
    ./Libraries/STM32F10x_StdPeriph_Driver/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group start
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group system
    ./System/: Delay.c Delay.h TIM.c TIM.h
  group Hardware
    ./Hardware/: KEY.c KEY.h BUZ.c BUZ.h OLED.c OLED.h OLED_Font.h PWM.c PWM.h Servo.c Servo.h Motor.c Motor.h MPU6050.c MPU6050.h MPU6050_Reg.h MeasureSpeed.c MeasureSpeed.h Encoder.c Encoder.h HC_SR04.c HC_SR04.h
  group HAL
    ./HAL/: HAL.h HAL_PWM.c HAL_PWM.h HAL_MeasureSpeed.c HAL_MeasureSpeed.h HAL_Motor.c HAL_Motor.h HAL_MPU6050.c HAL_MPU6050.h HAL_Servo.c HAL_Servo.h HAL_HC_SR04.c HAL_HC_SR04.h
  group Algorithm
    ./Algorithm/: MotorPID.h MotorPID.c Filtering.c Filtering.h Sorting.c Sorting.h
  group Application
    ./Application/: APP_ActionControl.c APP_ActionControl.h APP_Obstacle_Avoidance.c APP_Obstacle_Avoidance.h
